# Keil uVision project smaller.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODAT2
  output: smaller +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./class/: main.c 15io.h global.h uart.h uart.c wimiDevTimerStruct.h wimiDevTimerStruct.c wimiDevTimerManger.h wimiDevTimerManger.c smaller.h smaller.c NRF24L01.h NRF24L01.c
